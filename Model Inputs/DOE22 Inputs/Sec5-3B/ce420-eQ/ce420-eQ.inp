INPUT ..


$ ---------------------------------------------------------
$              Abort, Diagnostics
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Global Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Title, Run Periods, Design Days, Holidays
$ ---------------------------------------------------------

TITLE           
   LINE-1           = *J. Neymark & Associates/NREL*
   LINE-2           = *IEA SHC Task 22*
   LINE-3           = *Case E420 - Temperature Econo w/ ODB lim*
   ..

RUN-PERIOD-PD
   BEGIN-MONTH      = 1
   BEGIN-DAY        = 1
   BEGIN-YEAR       = 1967
   END-MONTH        = 12
   END-DAY          = 31
   END-YEAR         = 1967
   ..




$ ---------------------------------------------------------
$              Compliance Data
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Site and Building Data
$ ---------------------------------------------------------

"SITE-PARAMETERS 1" = SITE-PARAMETERS 
   LATITUDE         = 30
   LONGITUDE        = 90.3
   TIME-ZONE        = 6
   ALTITUDE         = 10
   DAYLIGHT-SAVINGS = NO
   GROUND-T         = ( 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 75.4, 
         75.4, 75.4, 75.4 )
   ..

"BUILD-PARAMETERS 1" = BUILD-PARAMETERS
   AZIMUTH          = 0
   GROSS-AREA       = 2110
   ..



PROJECT-DATA    
   ..


$ ---------------------------------------------------------
$              Materials / Layers / Constructions
$ ---------------------------------------------------------

"INSULATION" = MATERIAL        
   TYPE             = RESISTANCE
   RESISTANCE       = 1844.2
   ..


"LOW-MASS-WALL" = CONSTRUCTION    
   TYPE             = U-VALUE
   ABSORPTANCE      = 0.1
   ROUGHNESS        = 2
   U-VALUE          = 0.000542
   ..


$ ---------------------------------------------------------
$              Glass Type Codes
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Glass Types
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Window Layers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Lamps / Luminaries / Lighting Systems
$ ---------------------------------------------------------





$ ---------------------------------------------------------
$              Day Schedules
$ ---------------------------------------------------------

"ALL-DAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"LOW-SDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625, 0.15625, 0.15625, 0.15625 )
   ..
"11MAR-10APR-SDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625, 0.15625, 0.15625, 0.375, 0.375, 0.375, 0.375, 0.375, 0.375, 
         0.375, 0.375, 0.375, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625 )
   ..
"12APR-20APR-SDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625, 0.15625, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 
         0.5, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625 )
   ..
"21APR-12OCT-SDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0.375, 0.375, 0.375, 0.375, 0.375, 0.375, 0.375, 
         0.375, 0.5, 0.5, 0.5, 0.5, 0.75, 0.75, 1, 1, 0.5, 0.5, 0.5, 0.5, 
         0.375, 0.375, 0.375, 0.375 )
   ..
"13OCT-18OCT-SDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625, 0.15625, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 0.5, 0.15625, 
         0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625 )
   ..
"19OCT-05NOV-SDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 0.15625, 
         0.15625, 0.15625, 0.5, 0.5, 0.5, 0.5, 0.75, 0.75, 1, 1, 0.5, 0.5, 
         0.5, 0.5, 0.375, 0.375, 0.375, 0.375 )
   ..
"LOW-LDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 0.25, 0.25, 0.25, 0.25, 0.25, 
         0.25, 0.25, 0.25, 0.25, 0.25, 0.25, 0.25, 0, 0, 0, 0 )
   ..
"11MAR-10APR-LDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         0, 0, 0, 0, 0, 0 )
   ..
"12APR-20APR-LDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 0, 0, 0, 0, 0 )
   ..
"SUMMER-LDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 0, 0, 0, 0 )
   ..
"13OCT-18OCT-LDAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 
         0, 0, 0, 0, 0, 0 )
   ..
"Day Schedule  13" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule  14" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 
         32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32 )
   ..
"Day Schedule  15" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 77, 77, 77, 77, 77, 77, 77, 77, 77, 77, 77, 77, 77, 
         77, 77, 77, 77, 77, 77, 77, 77, 77, 77, 77 )
   ..
"Day Schedule  16" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule  17" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 
         0, 0, 0, 0, 0, 0 )
   ..
"Day Schedule  18" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..

$ ---------------------------------------------------------
$              Week Schedules
$ ---------------------------------------------------------

"ALL-WEEK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "ALL-DAY", "ALL-DAY", "ALL-DAY", "ALL-DAY", "ALL-DAY", 
         "ALL-DAY", "ALL-DAY", "ALL-DAY" )
   ..
"01JAN-10MAR-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", 
         "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", "LOW-SDAY" )
   ..
"11MAR-10APR-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "11MAR-10APR-SDAY", "11MAR-10APR-SDAY", 
         "11MAR-10APR-SDAY", "11MAR-10APR-SDAY", "11MAR-10APR-SDAY", 
         "11MAR-10APR-SDAY", "11MAR-10APR-SDAY", "11MAR-10APR-SDAY" )
   ..
"11APR-11APR-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", 
         "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", "LOW-SDAY" )
   ..
"12APR-20APR-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "12APR-20APR-SDAY", "12APR-20APR-SDAY", 
         "12APR-20APR-SDAY", "12APR-20APR-SDAY", "12APR-20APR-SDAY", 
         "12APR-20APR-SDAY", "12APR-20APR-SDAY", "12APR-20APR-SDAY" )
   ..
"21APR-12OCT-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "21APR-12OCT-SDAY", "21APR-12OCT-SDAY", 
         "21APR-12OCT-SDAY", "21APR-12OCT-SDAY", "21APR-12OCT-SDAY", 
         "21APR-12OCT-SDAY", "21APR-12OCT-SDAY", "21APR-12OCT-SDAY" )
   ..
"13OCT-18OCT-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "13OCT-18OCT-SDAY", "13OCT-18OCT-SDAY", 
         "13OCT-18OCT-SDAY", "13OCT-18OCT-SDAY", "13OCT-18OCT-SDAY", 
         "13OCT-18OCT-SDAY", "13OCT-18OCT-SDAY", "13OCT-18OCT-SDAY" )
   ..
"19OCT-05NOV-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "19OCT-05NOV-SDAY", "19OCT-05NOV-SDAY", 
         "19OCT-05NOV-SDAY", "19OCT-05NOV-SDAY", "19OCT-05NOV-SDAY", 
         "19OCT-05NOV-SDAY", "19OCT-05NOV-SDAY", "19OCT-05NOV-SDAY" )
   ..
"06NOV-31DEC-SWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", 
         "LOW-SDAY", "LOW-SDAY", "LOW-SDAY", "LOW-SDAY" )
   ..
"01JAN-10MAR-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", 
         "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", "LOW-LDAY" )
   ..
"11MAR-10APR-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "11MAR-10APR-LDAY", "11MAR-10APR-LDAY", 
         "11MAR-10APR-LDAY", "11MAR-10APR-LDAY", "11MAR-10APR-LDAY", 
         "11MAR-10APR-LDAY", "11MAR-10APR-LDAY", "11MAR-10APR-LDAY" )
   ..
"11APR-11APR-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", 
         "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", "LOW-LDAY" )
   ..
"12APR-20APR-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "12APR-20APR-LDAY", "12APR-20APR-LDAY", 
         "12APR-20APR-LDAY", "12APR-20APR-LDAY", "12APR-20APR-LDAY", 
         "12APR-20APR-LDAY", "12APR-20APR-LDAY", "12APR-20APR-LDAY" )
   ..
"21APR-12OCT-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "SUMMER-LDAY", "SUMMER-LDAY", "SUMMER-LDAY", 
         "SUMMER-LDAY", "SUMMER-LDAY", "SUMMER-LDAY", "SUMMER-LDAY", 
         "SUMMER-LDAY" )
   ..
"13OCT-18OCT-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "13OCT-18OCT-LDAY", "13OCT-18OCT-LDAY", 
         "13OCT-18OCT-LDAY", "13OCT-18OCT-LDAY", "13OCT-18OCT-LDAY", 
         "13OCT-18OCT-LDAY", "13OCT-18OCT-LDAY", "13OCT-18OCT-LDAY" )
   ..
"19OCT-05NOV-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "SUMMER-LDAY", "SUMMER-LDAY", "SUMMER-LDAY", 
         "SUMMER-LDAY", "SUMMER-LDAY", "SUMMER-LDAY", "SUMMER-LDAY", 
         "SUMMER-LDAY" )
   ..
"06NOV-31DEC-LWK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", 
         "LOW-LDAY", "LOW-LDAY", "LOW-LDAY", "LOW-LDAY" )
   ..
"Week Schedule 18" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule  13", "Day Schedule  13", 
         "Day Schedule  13", "Day Schedule  13", "Day Schedule  13", 
         "Day Schedule  13", "Day Schedule  13", "Day Schedule  13" )
   ..
"Week Schedule 19" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule  14", "Day Schedule  14", 
         "Day Schedule  14", "Day Schedule  14", "Day Schedule  14", 
         "Day Schedule  14", "Day Schedule  14", "Day Schedule  14" )
   ..
"Week Schedule 20" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule  15", "Day Schedule  15", 
         "Day Schedule  15", "Day Schedule  15", "Day Schedule  15", 
         "Day Schedule  15", "Day Schedule  15", "Day Schedule  15" )
   ..
"Week Schedule 21" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule  16", "Day Schedule  16", 
         "Day Schedule  16", "Day Schedule  16", "Day Schedule  16", 
         "Day Schedule  16", "Day Schedule  16", "Day Schedule  16" )
   ..
"Week Schedule 22" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule  17", "Day Schedule  17", 
         "Day Schedule  17", "Day Schedule  17", "Day Schedule  17", 
         "Day Schedule  17", "Day Schedule  17", "Day Schedule  17" )
   ..
"Week Schedule 23" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule  18", "Day Schedule  18", 
         "Day Schedule  18", "Day Schedule  18", "Day Schedule  18", 
         "Day Schedule  18", "Day Schedule  18", "Day Schedule  18" )
   ..

$ ---------------------------------------------------------
$              Annual Schedules
$ ---------------------------------------------------------

"LIT-S" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 3, 4, 4, 4, 10, 10, 11, 12 )
   DAY              = ( 10, 10, 11, 20, 12, 18, 5, 31 )
   WEEK-SCHEDULES   = ( "01JAN-10MAR-SWK", "11MAR-10APR-SWK", 
         "11APR-11APR-SWK", "12APR-20APR-SWK", "21APR-12OCT-SWK", 
         "13OCT-18OCT-SWK", "19OCT-05NOV-SWK", "06NOV-31DEC-SWK" )
   ..
"EQP-S" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 3, 4, 4, 4, 10, 10, 11, 12 )
   DAY              = ( 10, 10, 11, 20, 12, 18, 5, 31 )
   WEEK-SCHEDULES   = ( "01JAN-10MAR-LWK", "11MAR-10APR-LWK", 
         "11APR-11APR-LWK", "12APR-20APR-LWK", "21APR-12OCT-LWK", 
         "13OCT-18OCT-LWK", "19OCT-05NOV-LWK", "06NOV-31DEC-LWK" )
   ..
"INF-S" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "ALL-WEEK" )
   ..
"REP-SCH" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule 18" )
   ..
"HEAT-S" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule 19" )
   ..
"COOL-S" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule 20" )
   ..
"AHU-S" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule 21" )
   ..
"ALLOFF" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule 22" )
   ..
"ALL-MONTH-SCH" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule 23" )
   ..


$ ---------------------------------------------------------
$              Polygons
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Wall Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fixed and Building Shades
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Misc Cost Related Objects
$ ---------------------------------------------------------





$ *********************************************************
$ **                                                     **
$ **                Performance Curves                   **
$ **                                                     **
$ *********************************************************

"38AKS012-CSCFT" = CURVE-FIT       
   TYPE             = BI-QUADRATIC-T
   INPUT-TYPE       = DATA
   INDEPENDENT-1    = ( 67, 45, 45, 50, 55, 55, 55, 60, 60, 60, 65, 65, 70, 
         70, 75, 75, 75, 85, 85, 85 )
   INDEPENDENT-2    = ( 95, 55, 75, 95, 55, 75, 95, 55, 75, 95, 55, 75, 55, 
         75, 55, 75, 95, 55, 75, 95 )
   DEPENDENT        = ( 1, 2.168, 2.105, 1.813, 1.659, 1.637, 1.579, 1.38, 
         1.374, 1.312, 1.192, 1.141, 0.96, 0.913, 0.724, 0.68, 0.633, 0.245, 
         0.206, 0.164 )
   ..
"CONSTANT-BF-FT" = CURVE-FIT       
   TYPE             = BI-LINEAR-T
   INPUT-TYPE       = DATA
   OUTPUT-MIN       = 1
   OUTPUT-MAX       = 1
   INDEPENDENT-1    = ( 67, 59, 71, 59, 71 )
   INDEPENDENT-2    = ( 95, 85, 85, 115, 115 )
   DEPENDENT        = ( 1, 1, 1, 1, 1 )
   ..
"CONSTANT-BF-FPLR" = CURVE-FIT       
   TYPE             = LINEAR
   INPUT-TYPE       = DATA
   OUTPUT-MIN       = 1
   OUTPUT-MAX       = 1
   INDEPENDENT      = ( 1, 0 )
   DEPENDENT        = ( 1, 1 )
   ..
"38AKS012-CCAPFT" = CURVE-FIT       
   TYPE             = BI-QUADRATIC-T
   INPUT-TYPE       = DATA
   INDEPENDENT-1    = ( 67, 45, 45, 50, 55, 55, 55, 60, 60, 60, 65, 65, 70, 
         70, 75, 75, 75, 85, 85, 85 )
   INDEPENDENT-2    = ( 95, 55, 75, 95, 55, 75, 95, 55, 75, 95, 55, 75, 55, 
         75, 55, 75, 95, 55, 75, 95 )
   DEPENDENT        = ( 1, 0.825, 0.753, 0.738, 0.98, 0.898, 0.806, 1.07, 
         0.978, 0.885, 1.16, 1.068, 1.261, 1.164, 1.36, 1.256, 1.143, 1.581, 
         1.464, 1.336 )
   ..
"38AKS012-EIR-FT" = CURVE-FIT       
   TYPE             = BI-QUADRATIC-T
   INPUT-TYPE       = DATA
   INDEPENDENT-1    = ( 67, 45, 45, 50, 55, 55, 55, 60, 60, 60, 65, 65, 70, 
         70, 75, 75, 75, 85, 85, 85 )
   INDEPENDENT-2    = ( 95, 55, 75, 95, 55, 75, 95, 55, 75, 95, 55, 75, 55, 
         75, 55, 75, 95, 55, 75, 95 )
   DEPENDENT        = ( 1, 0.727, 0.942, 1.167, 0.654, 0.86, 1.115, 0.622, 
         0.822, 1.061, 0.594, 0.785, 0.566, 0.75, 0.544, 0.723, 0.938, 0.505, 
         0.672, 0.875 )
   ..
"TTP024C-CLOSFPLR" = CURVE-FIT       
   TYPE             = CUBIC
   INPUT-TYPE       = DATA
   OUTPUT-MIN       = 0.75
   OUTPUT-MAX       = 1
   INDEPENDENT      = ( 1, 0, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9 )
   DEPENDENT        = ( 1, 0.771, 0.794, 0.817, 0.84, 0.863, 0.886, 0.908, 
         0.931, 0.954, 0.977 )
   ..

$ *********************************************************
$ **                                                     **
$ **      Floors / Spaces / Walls / Windows / Doors      **
$ **                                                     **
$ *********************************************************

SET-DEFAULT FOR FLOOR           
   SHAPE            = NO-SHAPE
   FLOOR-HEIGHT     = {no_def}
   ..

SET-DEFAULT FOR SPACE           
   SHAPE            = NO-SHAPE
   ..

"DEFAULT-FLOOR" = FLOOR           
   C-DIAGRAM-DATA   = *Detailed UI DiagData*
   ..
"HVBT-SPACE" = SPACE           
   X                = 0
   Y                = 0
   Z                = 0
   AZIMUTH          = 0
   AREA             = 2109.7
   VOLUME           = 20765
   FLOOR-WEIGHT     = 0.74
   ZONE-TYPE        = CONDITIONED
   TEMPERATURE      = ( 77 )
   LIGHTING-SCHEDUL = ( "LIT-S" )
   EQUIP-SCHEDULE   = ( "EQP-S" )
   INF-SCHEDULE     = "INF-S"
   LIGHTING-TYPE    = ( SUS-FLUOR )
   INF-METHOD       = AIR-CHANGE
   INF-FLOW/AREA    = 0
   LIGHTING-KW      = ( 18.758 )
   LIGHT-TO-SPACE   = ( 1 )
   EQUIPMENT-KW     = ( 1.466 )
   EQUIP-LATENT     = ( 1 )
   EQUIP-SENSIBLE   = ( 0 )
   LIGHT-RAD-FRAC   = ( 0, 0 )
   ..
"N-WALL-EXT" = EXTERIOR-WALL   
   CONSTRUCTION     = "LOW-MASS-WALL"
   GND-REFLECTANCE  = 0.2
   OUTSIDE-EMISS    = 0.9
   INSIDE-SOL-ABS   = 0.6
   X                = 45.93
   Y                = 45.93
   Z                = 0
   HEIGHT           = 9.84
   WIDTH            = 45.93
   AZIMUTH          = 0
   TILT             = 90
   ..
"E-WALL-EXT" = EXTERIOR-WALL   
   LIKE = "N-WALL-EXT"
   Y                = 0
   WIDTH            = 45.93
   AZIMUTH          = 90
   ..
"S-WALL-EXT" = EXTERIOR-WALL   
   LIKE = "N-WALL-EXT"
   X                = 0
   Y                = 0
   AZIMUTH          = 180
   ..
"W-WALL-EXT" = EXTERIOR-WALL   
   LIKE = "N-WALL-EXT"
   X                = 0
   WIDTH            = 45.93
   AZIMUTH          = 270
   ..
"L-ROOF" = EXTERIOR-WALL   
   CONSTRUCTION     = "LOW-MASS-WALL"
   GND-REFLECTANCE  = 0
   OUTSIDE-EMISS    = 0.9
   INSIDE-SOL-ABS   = 0.6
   X                = 0
   Y                = 0
   Z                = 9.84
   HEIGHT           = 45.93
   WIDTH            = 45.93
   AZIMUTH          = 180
   TILT             = 0
   ..
"L-FLOOR" = EXTERIOR-WALL   
   CONSTRUCTION     = "LOW-MASS-WALL"
   GND-REFLECTANCE  = 0
   SKY-FORM-FACTOR  = 0
   GND-FORM-FACTOR  = 0
   OUTSIDE-EMISS    = 0.9
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.648
   X                = 0
   Y                = 45.93
   Z                = 0
   HEIGHT           = 45.93
   WIDTH            = 45.93
   AZIMUTH          = 180
   TILT             = 180
   ..


$ *********************************************************
$ **                                                     **
$ **              Electric & Fuel Meters                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Electric Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fuel Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Master Meters
$ ---------------------------------------------------------

"MASTER-METERS 1" = MASTER-METERS   
   MSTR-ELEC-METER  = "EM1"
   MSTR-FUEL-METER  = "FM1"
   ..


$ *********************************************************
$ **                                                     **
$ **      HVAC Circulation Loops / Plant Equipment       **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Pumps
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Circulation Loops
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chillers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Boilers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Domestic Water Heaters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Rejection
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Tower Free Cooling
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Photovoltaic Modules
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Electric Generators
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Thermal Storage
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Ground Loop Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Compliance DHW (residential dwelling units)
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **            Steam & Chilled Water Meters             **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Steam Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chilled Water Meters
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **               HVAC Systems / Zones                  **
$ **                                                     **
$ *********************************************************

"SYSTEM-1" = SYSTEM          
   TYPE             = PSZ
   RETURN-AIR-PATH  = DUCT
   MAX-SUPPLY-T     = 105
   HEATING-SCHEDULE = "ALLOFF"
   MIN-SUPPLY-T     = 35
   COOLING-SCHEDULE = "AHU-S"
   ECONO-LIMIT-T    = 68
   ECONO-LOCKOUT    = NO
   SUPPLY-FLOW      = 4000
   MIN-OUTSIDE-AIR  = 0.15
   OA-CONTROL       = OA-TEMP
   FAN-SCHEDULE     = "AHU-S"
   FAN-CONTROL      = CONSTANT-VOLUME
   SUPPLY-DELTA-T   = 0.96
   SUPPLY-KW/FLOW   = 0.0003105
   MOTOR-PLACEMENT  = IN-AIRFLOW
   FAN-PLACEMENT    = DRAW-THROUGH
   MAX-FAN-RATIO    = 1
   MIN-FAN-RATIO    = 1
   NIGHT-CYCLE-CTRL = STAY-OFF
   INDOOR-FAN-MODE  = CONTINUOUS
   COOLING-CAPACITY = 113535
   COOL-CAP-FT      = "38AKS012-CCAPFT"
   COOLING-EIR      = 0.3007
   COOL-EIR-FT      = "38AKS012-EIR-FT"
   COOL-SH-CAP      = 88852
   COOL-SH-FT       = "38AKS012-CSCFT"
   COIL-BF          = 0.07
   COIL-BF-FT       = "CONSTANT-BF-FT"
   COOL-CTRL-RANGE  = 0
   MIN-UNLOAD-RATIO = 1
   MIN-HGB-RATIO    = 1
   CRANKCASE-HEAT   = 0
   OUTSIDE-FAN-ELEC = 0.0081913
   OUTSIDE-FAN-T    = 24
   OUTSIDE-FAN-MODE = INTERMITTENT
   COMPRESSOR-TYPE  = SINGLE-SPEED
   FURNACE-AUX      = 0
   COOL-FT-MIN      = 50
   CRANKCASE-MAX-T  = 24
   CONDENSER-TYPE   = AIR-COOLED
   COIL-BF-FPLR     = "CONSTANT-BF-FPLR"
   COOL-CLOSS-FPLR  = "TTP024C-CLOSFPLR"
   COOL-CLOSS-MIN   = 0
   CONTROL-ZONE     = "HVBT-ZONE"
   ..
"HVBT-ZONE" = ZONE            
   TYPE             = CONDITIONED
   ASSIGNED-FLOW    = 4000
   DESIGN-HEAT-T    = 70
   HEAT-TEMP-SCH    = "HEAT-S"
   DESIGN-COOL-T    = 78
   COOL-TEMP-SCH    = "COOL-S"
   THERMOSTAT-TYPE  = TWO-POSITION
   THROTTLING-RANGE = 0.1
   SPACE            = "HVBT-SPACE"
   ..


$ *********************************************************
$ **                                                     **
$ **                Metering & Misc HVAC                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Equipment Controls
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Load Management
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                    Utility Rates                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Ratchets
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Block Charges
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Utility Rates
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                 Output Reporting                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Loads Non-Hourly Reporting
$ ---------------------------------------------------------

LOADS-REPORT    
   VERIFICATION     = ( LV-N )
   SUMMARY          = ( LS-D )
   REPORT-FREQUENCY = HOURLY
   ..


$ ---------------------------------------------------------
$              Systems Non-Hourly Reporting
$ ---------------------------------------------------------

SYSTEMS-REPORT  
   SUMMARY          = ( SS-A, SS-I )
   REPORT-FREQUENCY = HOURLY
   ..


$ ---------------------------------------------------------
$              Plant Non-Hourly Reporting
$ ---------------------------------------------------------

PLANT-REPORT    
   SUMMARY          = ( PS-E, PS-F )
   ..


$ ---------------------------------------------------------
$              Economics Non-Hourly Reporting
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Hourly Reporting
$ ---------------------------------------------------------

"BLDC1" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 19 )
   ..
"BLDC2" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 20 )
   ..
"BLDC3" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 21 )
   ..
"BLDC4" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 22 )
   ..
"BLDC9" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 27 )
   ..
"BLDC10" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 28 )
   ..
"BLDC12" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 30 )
   ..
"BLDC16" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 34 )
   ..
"TM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 3 )
   ..
"WM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 36 )
   ..
"SKWQC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 47 )
   ..
"EIR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 68 )
   ..
"EIRM1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 66 )
   ..
"EIRM2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 67 )
   ..
"SFKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 49 )
   ..
"OFKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 69 )
   ..
"CON" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 25 )
   ..
"CFM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 17 )
   ..
"CINF" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 22 )
   ..
"PO" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 39 )
   ..
"QCT" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 70 )
   ..
"QCM1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 63 )
   ..
"QCS" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 71 )
   ..
"QCM2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 64 )
   ..
"QC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 6 )
   ..
"QNOW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 8 )
   ..
"QCLAT" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 48 )
   ..
"QS" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 1 )
   ..
"QL" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 2 )
   ..
"TNOW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 6 )
   ..
"TAVE" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 31 )
   ..
"WR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 35 )
   ..
"DBT" = REPORT-BLOCK    
   VARIABLE-TYPE    = GLOBAL
   VARIABLE-LIST    = ( 8 )
   ..
"TCZ" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 18 )
   ..
"WCOIL" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 37 )
   ..
"WW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 38 )
   ..
"HUMRAT" = REPORT-BLOCK    
   VARIABLE-TYPE    = GLOBAL
   VARIABLE-LIST    = ( 10 )
   ..
"PLRC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 61 )
   ..
"PLRCC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 210 )
   ..
"CLPLR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 211 )
   ..
"CLOSFPLR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 191 )
   ..
"TSURF" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 54 )
   ..
"CBF" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 56 )
   ..
"CBF1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 57 )
   ..
"BFFPLR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 175 )
   ..
"CBF2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 58 )
   ..
"TC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 2 )
   ..
"TCMIN" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 13 )
   ..
"PATM" = REPORT-BLOCK    
   VARIABLE-TYPE    = GLOBAL
   VARIABLE-LIST    = ( 5 )
   ..
"QCZ" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 8 )
   ..
"RCFM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 20 )
   ..
"ECFM" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 21 )
   ..
"SKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 32 )
   ..
"FANKW" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 33 )
   ..
"PCH" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 75 )
   ..
"QHSUP" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 81 )
   ..
"ZQC" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 33 )
   ..
"FCx" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 13 )
   ..
"CFMZ" = REPORT-BLOCK    
   VARIABLE-TYPE    = "HVBT-ZONE"
   VARIABLE-LIST    = ( 14 )
   ..
"DTON" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 100 )
   ..
"QCLOAD" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 156 )
   ..
"QCFAN" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 164 )
   ..
"WBR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 92 )
   ..
"QCRUN" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-1"
   VARIABLE-LIST    = ( 155 )
   ..

"LOADS-RPT" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "REP-SCH"
   REPORT-BLOCK     = ( "BLDC1", "BLDC2", "BLDC3", "BLDC4", "BLDC9", "BLDC10", 
         "BLDC12", "BLDC16" )
   ..
"R#1P-DOE2-PRELIM" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "ALL-MONTH-SCH"
   REPORT-BLOCK     = ( "SKWQC", "OFKW", "SFKW", "QC", "QCLAT", "TAVE", "WR", 
         "PATM" )
   ..


$ ---------------------------------------------------------
$              THE END
$ ---------------------------------------------------------

END ..
COMPUTE ..
STOP ..
