INPUT ..


$ ---------------------------------------------------------
$              Abort, Diagnostics
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Global Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Title, Run Periods, Design Days, Holidays
$ ---------------------------------------------------------

TITLE           
   LINE-1           = *James J. Hirsch & Associates*
   LINE-2           = *ASHRAE Standard 140 Tests*
   LINE-3           = *Case 980*
   ..

RUN-PERIOD-PD
   BEGIN-MONTH      = 1
   BEGIN-DAY        = 1
   BEGIN-YEAR       = 1988
   END-MONTH        = 12
   END-DAY          = 31
   END-YEAR         = 1988
   ..




$ ---------------------------------------------------------
$              Compliance Data
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Site and Building Data
$ ---------------------------------------------------------

"SITE-PARAMETERS 1" = SITE-PARAMETERS 
   LATITUDE         = 39.833
   LONGITUDE        = 104.65
   TIME-ZONE        = 7
   ALTITUDE         = 5413
   DAYLIGHT-SAVINGS = NO
   GROUND-T         = ( 49.5, 49.5, 49.5, 49.5, 49.5, 49.5, 49.5, 49.5, 49.5, 
         49.5, 49.5, 49.5 )
   ..

"BUILD-PARAMETERS 1" = BUILD-PARAMETERS
   AZIMUTH          = 0
   GROSS-AREA       = 516.7
   ..



PROJECT-DATA    
   ..


$ ---------------------------------------------------------
$              Materials / Layers / Constructions
$ ---------------------------------------------------------

"WOOD-SIDING" = MATERIAL        
   TYPE             = PROPERTIES
   THICKNESS        = 0.03
   CONDUCTIVITY     = 0.081
   DENSITY          = 33.087
   SPECIFIC-HEAT    = 0.215
   ..
"FOAM-INSUL" = MATERIAL        
   TYPE             = PROPERTIES
   THICKNESS        = 0.804
   CONDUCTIVITY     = 0.02311
   DENSITY          = 0.624
   SPECIFIC-HEAT    = 0.334
   ..
"CONCRETE-BLK" = MATERIAL        
   TYPE             = PROPERTIES
   THICKNESS        = 0.328
   CONDUCTIVITY     = 0.295
   DENSITY          = 87.399
   SPECIFIC-HEAT    = 0.239
   ..
"CONCRETE-SLAB" = MATERIAL        
   TYPE             = PROPERTIES
   THICKNESS        = 0.262
   CONDUCTIVITY     = 0.653
   DENSITY          = 87.399
   SPECIFIC-HEAT    = 0.239
   ..
"INSUL-FLOOR-HM" = MATERIAL        
   TYPE             = RESISTANCE
   RESISTANCE       = 142.855
   ..
"PLASTER-ROOF" = MATERIAL        
   TYPE             = PROPERTIES
   THICKNESS        = 0.033
   CONDUCTIVITY     = 0.093
   DENSITY          = 59.307
   SPECIFIC-HEAT    = 0.201
   ..
"FIBERGLAS-RF" = MATERIAL        
   TYPE             = PROPERTIES
   THICKNESS        = 1.312
   CONDUCTIVITY     = 0.02311
   DENSITY          = 0.749
   SPECIFIC-HEAT    = 0.201
   ..
"ROOFDECK" = MATERIAL        
   TYPE             = PROPERTIES
   THICKNESS        = 0.062
   CONDUCTIVITY     = 0.081
   DENSITY          = 33.087
   SPECIFIC-HEAT    = 0.215
   ..

"WALL-HI-MASS-LA" = LAYERS          
   INSIDE-FILM-RES  = 0.684
   MATERIAL         = ( "WOOD-SIDING", "FOAM-INSUL", "CONCRETE-BLK" )
   ..
"FLOOR-HI-MASS-LA" = LAYERS          
   INSIDE-FILM-RES  = 0.684
   MATERIAL         = ( "INSUL-FLOOR-HM", "CONCRETE-SLAB" )
   ..
"ROOF-LOW-MASS-LA" = LAYERS          
   INSIDE-FILM-RES  = 0.684
   MATERIAL         = ( "ROOFDECK", "FIBERGLAS-RF", "PLASTER-ROOF" )
   ..

"HIGH-MASS-WALL" = CONSTRUCTION    
   TYPE             = LAYERS
   ABSORPTANCE      = 0.6
   ROUGHNESS        = 2
   LAYERS           = "WALL-HI-MASS-LA"
   ..
"HIGH-MASS-FLOOR" = CONSTRUCTION    
   TYPE             = LAYERS
   LAYERS           = "FLOOR-HI-MASS-LA"
   ..
"LOW-MASS-ROOF" = CONSTRUCTION    
   TYPE             = LAYERS
   ABSORPTANCE      = 0.6
   ROUGHNESS        = 2
   LAYERS           = "ROOF-LOW-MASS-LA"
   ..


$ ---------------------------------------------------------
$              Glass Type Codes
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Glass Types
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Window Layers
$ ---------------------------------------------------------

"GLASS-STD140-600" = WINDOW-LAYER    
   TYPE             = GLASS
   TRANS-SOL-BB     = 0.834
   REFL-SOL-BB      = 0.075
   BACKREFL-SOL-BB  = 0.075
   TRANS-VIS-BB     = 0.898
   REFL-VIS-BB      = 0.081
   BACKREFL-VIS-BB  = 0.081
   EMIS-IR          = 0.84
   BACKEMIS-IR      = 0.84
   THICKNESS        = 0.01000
   CONDUCTIVITY     = 0.57779
   ..
"AIR-GAP-STD140-600" = WINDOW-LAYER    
   TYPE             = GAP
   THICKNESS        = 0.03937
   CONDUCTIVITY     = 0.013907
   D-CONDUCTIVITY   = 2.43954
   VISCOSITY        = 1.1423473
   D-VISCOSITY      = 3.7332
   DENSITY          = 0.08069
   D-DENSITY        = -0.0001526
   PRANDTL-NUMB     = 0.7197
   D-PRANDTL-NUMB   = 0.001
   ..


$ ---------------------------------------------------------
$              Lamps / Luminaries / Lighting Systems
$ ---------------------------------------------------------





$ ---------------------------------------------------------
$              Day Schedules
$ ---------------------------------------------------------

"ALL-DAY" = DAY-SCHEDULE-PD
   TYPE             = FRACTION
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   3" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   4" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 
         68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68 )
   ..
"Day Schedule   5" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 
         80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 80.6, 
         80.6, 80.6, 80.6, 80.6 )
   ..
"Day Schedule   6" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   7" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 
         0, 0, 0, 0, 0, 0 )
   ..
"Day Schedule   8" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   9" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 
         0, 0, 0, 0, 0, 0 )
   ..

$ ---------------------------------------------------------
$              Week Schedules
$ ---------------------------------------------------------

"ALL-WEEK" = WEEK-SCHEDULE-PD
   TYPE             = FRACTION
   DAY-SCHEDULES    = ( "ALL-DAY", "ALL-DAY", "ALL-DAY", "ALL-DAY", "ALL-DAY", 
         "ALL-DAY", "ALL-DAY", "ALL-DAY" )
   ..
"Week Schedule  3" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3" )
   ..
"Week Schedule  4" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4" )
   ..
"Week Schedule  5" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5" )
   ..
"Week Schedule  6" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   6", "Day Schedule   6", 
         "Day Schedule   6", "Day Schedule   6", "Day Schedule   6", 
         "Day Schedule   6", "Day Schedule   6", "Day Schedule   6" )
   ..
"Week Schedule  7" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   7", "Day Schedule   7", 
         "Day Schedule   7", "Day Schedule   7", "Day Schedule   7", 
         "Day Schedule   7", "Day Schedule   7", "Day Schedule   7" )
   ..
"Week Schedule  8" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   8", "Day Schedule   8", 
         "Day Schedule   8", "Day Schedule   8", "Day Schedule   8", 
         "Day Schedule   8", "Day Schedule   8", "Day Schedule   8" )
   ..
"Week Schedule  9" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   9", "Day Schedule   9", 
         "Day Schedule   9", "Day Schedule   9", "Day Schedule   9", 
         "Day Schedule   9", "Day Schedule   9", "Day Schedule   9" )
   ..

$ ---------------------------------------------------------
$              Annual Schedules
$ ---------------------------------------------------------

"LIT-S" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "ALL-WEEK" )
   ..
"INF-S" = SCHEDULE-PD
   TYPE             = FRACTION
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "ALL-WEEK" )
   ..
"REP-SCH" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  3" )
   ..
"HEAT-S" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  4" )
   ..
"COOL-S" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  5" )
   ..
"AHU-S" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  6" )
   ..
"FEB1-JUL14-SCH" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 1, 2, 7, 7, 12 )
   DAY              = ( 31, 1, 13, 14, 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  7", "Week Schedule  8", 
         "Week Schedule  7", "Week Schedule  8", "Week Schedule  9" )
   ..


$ ---------------------------------------------------------
$              Polygons
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Wall Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fixed and Building Shades
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Misc Cost Related Objects
$ ---------------------------------------------------------





$ *********************************************************
$ **                                                     **
$ **                Performance Curves                   **
$ **                                                     **
$ *********************************************************


$ *********************************************************
$ **                                                     **
$ **      Floors / Spaces / Walls / Windows / Doors      **
$ **                                                     **
$ *********************************************************

SET-DEFAULT FOR FLOOR           
   SHAPE            = NO-SHAPE
   FLOOR-HEIGHT     = {no_def}
   ..

SET-DEFAULT FOR SPACE           
   SHAPE            = NO-SHAPE
   ..

"DEFAULT-FLOOR" = FLOOR           
   C-DIAGRAM-DATA   = *Detailed UI DiagData*
   ..
"WF-EXTERNAL" = WEIGHTING-FACTOR
   FACTOR-LIST = ( 0.961604952, -1.21717074, 0.255565787,
      0, -1.13133144, 0.191471354,
      0.113358605, -0.0428025582, -0.0200981079,
      1.20260434, -0.260553522, 0.1501194,
      -0.0686746471, -0.028363373, 1.12649544,
      -0.187067605, 0.1501194, -0.0686746471,
      -0.028363373, 1.12649544, -0.187067605,
      0.1501194, -0.0686746471, -0.028363373,
      1.12649544, -0.187067605, 0.402042285,
      -0.382235476, 0.0354950011, 1.12649544,
      -0.187067605 )
   ..
"SHOEBOX" = SPACE           
   HEIGHT           = 8.86
   SHAPE            = BOX
   WIDTH            = 26.25
   DEPTH            = 19.69
   WEIGHTING-FACTOR = "WF-EXTERNAL"
   ZONE-TYPE        = CONDITIONED
   TEMPERATURE      = ( 74.3 )
   INF-SCHEDULE     = "INF-S"
   INF-METHOD       = AIR-CHANGE
   INF-FLOW/AREA    = 0.0738
   LIGHTING-SCHEDUL = ( "LIT-S" )
   LIGHTING-TYPE    = ( SUS-FLUOR )
   LIGHTING-KW      = ( 0.2 )
   LIGHT-TO-SPACE   = ( 1 )
   LIGHT-RAD-FRAC   = ( 0.6, 1 )
   ..
"N-WALL-EXT" = EXTERIOR-WALL   
   CONSTRUCTION     = "HIGH-MASS-WALL"
   GND-REFLECTANCE  = 0.2
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.068
   LOCATION         = BACK
   ..
"E-WALL-EXT" = EXTERIOR-WALL   
   CONSTRUCTION     = "HIGH-MASS-WALL"
   GND-REFLECTANCE  = 0.2
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.051
   LOCATION         = RIGHT
   ..
"S-WALL-EXT" = EXTERIOR-WALL   
   CONSTRUCTION     = "HIGH-MASS-WALL"
   GND-REFLECTANCE  = 0.2
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.031
   LOCATION         = FRONT
   ..
"S-WINDOW-1" = WINDOW          
   WIN-SPEC-METHOD  = LAYERS-INPUT
   X                = 1.64
   Y                = 0.66
   HEIGHT           = 6.56
   WIDTH            = 9.84
   WINDOW-LAYERS    = ( "GLASS-STD140-600", "AIR-GAP-STD140-600", 
         "GLASS-STD140-600" )
   ..
"S-WINDOW-2" = WINDOW          
   WIN-SPEC-METHOD  = LAYERS-INPUT
   X                = 14.76
   Y                = 0.66
   HEIGHT           = 6.56
   WIDTH            = 9.84
   WINDOW-LAYERS    = ( "GLASS-STD140-600", "AIR-GAP-STD140-600", 
         "GLASS-STD140-600" )
   ..
"W-WALL-EXT" = EXTERIOR-WALL   
   CONSTRUCTION     = "HIGH-MASS-WALL"
   GND-REFLECTANCE  = 0.2
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.051
   LOCATION         = LEFT
   ..
"L-ROOF" = EXTERIOR-WALL   
   CONSTRUCTION     = "LOW-MASS-ROOF"
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.151
   LOCATION         = TOP
   ..
"L-FLOOR" = EXTERIOR-WALL
   CONSTRUCTION     = "HIGH-MASS-FLOOR"
   INSIDE-SOL-ABS   = 0.6
   SOLAR-FRACTION   = 0.648
   LOCATION         = BOTTOM
   ..


$ *********************************************************
$ **                                                     **
$ **              Electric & Fuel Meters                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Electric Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fuel Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Master Meters
$ ---------------------------------------------------------

"MASTER-METERS 1" = MASTER-METERS   
   MSTR-ELEC-METER  = "EM1"
   MSTR-FUEL-METER  = "FM1"
   ..


$ *********************************************************
$ **                                                     **
$ **      HVAC Circulation Loops / Plant Equipment       **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Pumps
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Condensing Units
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Circulation Loops
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chillers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Boilers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Domestic Water Heaters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Rejection
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Tower Free Cooling
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Photovoltaic Modules
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Electric Generators
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Thermal Storage
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Ground Loop Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Compliance DHW (residential dwelling units)
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **            Steam & Chilled Water Meters             **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Steam Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chilled Water Meters
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **               HVAC Systems / Zones                  **
$ **                                                     **
$ *********************************************************

"SYSTEM-SUM" = SYSTEM          
   TYPE             = SUM
   HEATING-SCHEDULE = "AHU-S"
   COOLING-SCHEDULE = "AHU-S"
   ..
"SHOEBOX-ZONE" = ZONE            
   TYPE             = CONDITIONED
   MAX-HEAT-RATE    = -3.413e+006
   MAX-COOL-RATE    = 3.413e+006
   DESIGN-HEAT-T    = 68
   HEAT-TEMP-SCH    = "HEAT-S"
   DESIGN-COOL-T    = 80.6
   COOL-TEMP-SCH    = "COOL-S"
   THERMOSTAT-TYPE  = TWO-POSITION
   THROTTLING-RANGE = 0.1
   SPACE            = "SHOEBOX"
   ..


$ *********************************************************
$ **                                                     **
$ **                Metering & Misc HVAC                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Equipment Controls
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Load Management
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                    Utility Rates                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Ratchets
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Block Charges
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Utility Rates
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                 Output Reporting                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Loads Non-Hourly Reporting
$ ---------------------------------------------------------

LOADS-REPORT    
   ..


$ ---------------------------------------------------------
$              Systems Non-Hourly Reporting
$ ---------------------------------------------------------

SYSTEMS-REPORT
   SUMMARY = ( SS-A, SS-D, SS-G, SS-I )
   ..


$ ---------------------------------------------------------
$              Plant Non-Hourly Reporting
$ ---------------------------------------------------------

PLANT-REPORT    
   ..


$ ---------------------------------------------------------
$              Economics Non-Hourly Reporting
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Hourly Reporting
$ ---------------------------------------------------------

"N-WL-HR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "N-WALL-EXT"
   VARIABLE-LIST    = ( 1 )
   ..
"W-WL-HR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "W-WALL-EXT"
   VARIABLE-LIST    = ( 1 )
   ..
"S-WL-HR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "S-WALL-EXT"
   VARIABLE-LIST    = ( 1 )
   ..
"E-WL-HR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "E-WALL-EXT"
   VARIABLE-LIST    = ( 1 )
   ..
"WIN-1-HR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "S-WINDOW-1"
   VARIABLE-LIST    = ( 13 )
   ..
"WIN-2-HR" = REPORT-BLOCK    
   VARIABLE-TYPE    = "S-WINDOW-2"
   VARIABLE-LIST    = ( 13 )
   ..
"HOR-RAD" = REPORT-BLOCK    
   VARIABLE-TYPE    = GLOBAL
   VARIABLE-LIST    = ( 15 )
   ..
"BLDDTH5" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 5 )
   ..
"BLDDTC5" = REPORT-BLOCK    
   VARIABLE-TYPE    = BUILDING-LOADS
   VARIABLE-LIST    = ( 23 )
   ..
"HTG-LOAD" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-SUM"
   VARIABLE-LIST    = ( 7 )
   ..
"CLG-LOAD" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-SUM"
   VARIABLE-LIST    = ( 6 )
   ..
"HTG-LOAD-5" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SYSTEM-SUM"
   VARIABLE-LIST    = ( 5 )
   ..

"ANNRAD-REP" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "REP-SCH"
   REPORT-BLOCK     = ( "N-WL-HR", "W-WL-HR", "S-WL-HR", "E-WL-HR", 
         "WIN-1-HR", "WIN-2-HR", "HOR-RAD" )
   ..
"WINDOW-CON" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "REP-SCH"
   REPORT-BLOCK     = ( "BLDDTH5", "BLDDTC5" )
   ..
"HTGLOAD-REP" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "FEB1-JUL14-SCH"
   REPORT-BLOCK     = ( "HTG-LOAD" )
   ..
"CLGLOAD-REP" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "FEB1-JUL14-SCH"
   REPORT-BLOCK     = ( "CLG-LOAD" )
   ..
"DUMMY-REP" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "FEB1-JUL14-SCH"
   REPORT-BLOCK     = ( "HTG-LOAD-5" )
   ..


$ ---------------------------------------------------------
$              THE END
$ ---------------------------------------------------------

END ..
COMPUTE ..
STOP ..
