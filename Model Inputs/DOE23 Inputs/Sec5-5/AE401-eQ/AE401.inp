INPUT ..


$ ---------------------------------------------------------
$              Abort, Diagnostics
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Global Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Title, Run Periods, Design Days, Holidays
$ ---------------------------------------------------------

TITLE           
   LINE-1           = * AE401 Building Description*
   LINE-2           = * Field Trial Conditions - DOE2.3 - Round*
   ..

RUN-PERIOD-PD
   BEGIN-MONTH      = 1
   BEGIN-DAY        = 1
   BEGIN-YEAR       = 1988
   END-MONTH        = 12
   END-DAY          = 31
   END-YEAR         = 1988
   ..

"HEATING-DESIGN" = DESIGN-DAY      
   TYPE             = HEATING
   DRYBULB-HIGH     = -20.2
   DRYBULB-RANGE    = 0
   WETBULB-AT-HIGH  = -20.2
   HOUR-HIGH        = 16
   HOUR-LOW         = 2
   WIND-SPEED       = 9.62
   WIND-DIR         = N
   CLOUD-AMOUNT     = 10
   GROUND-T         = -20
   CLIMATE          = MIDLATITUDE
   VISIBILITY       = LOW
   NUMBER-OF-DAYS   = 4
   ..

"WORKSALOT" = HOLIDAYS        
   TYPE             = NONE
   ..


$ ---------------------------------------------------------
$              Compliance Data
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Site and Building Data
$ ---------------------------------------------------------

"SITE-PARAMETERS 1" = SITE-PARAMETERS 
   LATITUDE         = 25.8
   LONGITUDE        = 80.26
   TIME-ZONE        = 6
   ALTITUDE         = 0
   DAYLIGHT-SAVINGS = NO
   SHIELDING-COEF   = 0.32
   TERRAIN-PAR1     = 1.3
   TERRAIN-PAR2     = 0.1
   WS-TERRAIN-PAR1  = 1.3
   WS-TERRAIN-PAR2  = 0.1
   WS-HEIGHT        = 8
   ..

"BUILD-PARAMETERS 1" = BUILD-PARAMETERS
   AZIMUTH          = 0
   HOLIDAYS         = "WORKSALOT"
   ..



PROJECT-DATA    
   ..


$ ---------------------------------------------------------
$              Materials / Layers / Constructions
$ ---------------------------------------------------------


"INTLAYERS" = LAYERS          
   MATERIAL         = ( "Conc HW 140lb 4in (CC03)" )
   ..

"INTCONS" = CONSTRUCTION    
   TYPE             = LAYERS
   LAYERS           = "INTLAYERS"
   ..
"EXTCONS" = CONSTRUCTION    
   TYPE             = U-VALUE
   ABSORPTANCE      = 0
   ROUGHNESS        = 1
   U-VALUE          = 0.0626841
   ..


$ ---------------------------------------------------------
$              Glass Type Codes
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Glass Types
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Window Layers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Lamps / Luminaries / Lighting Systems
$ ---------------------------------------------------------





$ ---------------------------------------------------------
$              Day Schedules
$ ---------------------------------------------------------

"Day Schedule   1" = DAY-SCHEDULE-PD
   TYPE             = MULTIPLIER
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   2" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   3" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   4" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule   5" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 
         70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 
         70.5, 70.5, 70.5, 70.5 )
   ..
"Day Schedule   6" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 
         70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 70.5, 
         70.5, 70.5, 70.5, 70.5 )
   ..
"Day Schedule   7" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 
         72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 
         72.3, 72.3, 72.3, 72.3 )
   ..
"Day Schedule   8" = DAY-SCHEDULE-PD
   TYPE             = TEMPERATURE
   VALUES           = ( 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 
         72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 72.3, 
         72.3, 72.3, 72.3, 72.3 )
   ..
"Day Schedule   9" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule  10" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule  11" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..
"Day Schedule  12" = DAY-SCHEDULE-PD
   TYPE             = ON/OFF
   VALUES           = ( 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 
         1, 1, 1, 1, 1, 1 )
   ..

$ ---------------------------------------------------------
$              Week Schedules
$ ---------------------------------------------------------

"Week Schedule  1" = WEEK-SCHEDULE-PD
   TYPE             = MULTIPLIER
   DAY-SCHEDULES    = ( "Day Schedule   1", "Day Schedule   1", 
         "Day Schedule   1", "Day Schedule   1", "Day Schedule   1", 
         "Day Schedule   1", "Day Schedule   1", "Day Schedule   1" )
   ..
"Week Schedule  2" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   2", "Day Schedule   2", 
         "Day Schedule   2", "Day Schedule   2", "Day Schedule   2", 
         "Day Schedule   2", "Day Schedule   2", "Day Schedule   2" )
   ..
"Week Schedule  3" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3", 
         "Day Schedule   3", "Day Schedule   3", "Day Schedule   3" )
   ..
"Week Schedule  4" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4", 
         "Day Schedule   4", "Day Schedule   4", "Day Schedule   4" )
   ..
"Week Schedule  5" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5", 
         "Day Schedule   5", "Day Schedule   5", "Day Schedule   5" )
   ..
"Week Schedule  6" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   6", "Day Schedule   6", 
         "Day Schedule   6", "Day Schedule   6", "Day Schedule   6", 
         "Day Schedule   6", "Day Schedule   6", "Day Schedule   6" )
   ..
"Week Schedule  7" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   7", "Day Schedule   7", 
         "Day Schedule   7", "Day Schedule   7", "Day Schedule   7", 
         "Day Schedule   7", "Day Schedule   7", "Day Schedule   7" )
   ..
"Week Schedule  8" = WEEK-SCHEDULE-PD
   TYPE             = TEMPERATURE
   DAY-SCHEDULES    = ( "Day Schedule   8", "Day Schedule   8", 
         "Day Schedule   8", "Day Schedule   8", "Day Schedule   8", 
         "Day Schedule   8", "Day Schedule   8", "Day Schedule   8" )
   ..
"Week Schedule  9" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule   9", "Day Schedule   9", 
         "Day Schedule   9", "Day Schedule   9", "Day Schedule   9", 
         "Day Schedule   9", "Day Schedule   9", "Day Schedule   9" )
   ..
"Week Schedule 10" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule  10", "Day Schedule  10", 
         "Day Schedule  10", "Day Schedule  10", "Day Schedule  10", 
         "Day Schedule  10", "Day Schedule  10", "Day Schedule  10" )
   ..
"Week Schedule 11" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule  11", "Day Schedule  11", 
         "Day Schedule  11", "Day Schedule  11", "Day Schedule  11", 
         "Day Schedule  11", "Day Schedule  11", "Day Schedule  11" )
   ..
"Week Schedule 12" = WEEK-SCHEDULE-PD
   TYPE             = ON/OFF
   DAY-SCHEDULES    = ( "Day Schedule  12", "Day Schedule  12", 
         "Day Schedule  12", "Day Schedule  12", "Day Schedule  12", 
         "Day Schedule  12", "Day Schedule  12", "Day Schedule  12" )
   ..

$ ---------------------------------------------------------
$              Annual Schedules
$ ---------------------------------------------------------

"Constant" = SCHEDULE-PD
   TYPE             = MULTIPLIER
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  1" )
   ..
"LDS-REPORT-A" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12, 12, 12 )
   DAY              = ( 20, 21, 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  2", "Week Schedule  3", 
         "Week Schedule  4" )
   ..
"HEAT-A" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  5" )
   ..
"COOL-A" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  6" )
   ..
"HEAT-B" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  7" )
   ..
"COOL-B" = SCHEDULE-PD
   TYPE             = TEMPERATURE
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  8" )
   ..
"ALWAYS-ON" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12 )
   DAY              = ( 31 )
   WEEK-SCHEDULES   = ( "Week Schedule  9" )
   ..
"SCH-REPORT-A" = SCHEDULE-PD
   TYPE             = ON/OFF
   MONTH            = ( 12, 12, 12 )
   DAY              = ( 20, 21, 31 )
   WEEK-SCHEDULES   = ( "Week Schedule 10", "Week Schedule 11", 
         "Week Schedule 12" )
   ..


$ ---------------------------------------------------------
$              Polygons
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Wall Parameters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fixed and Building Shades
$ ---------------------------------------------------------




$ ---------------------------------------------------------
$              Misc Cost Related Objects
$ ---------------------------------------------------------





$ *********************************************************
$ **                                                     **
$ **                Performance Curves                   **
$ **                                                     **
$ *********************************************************

"ALWAYS1-LINEAR" = CURVE-FIT       
   TYPE             = LINEAR
   INPUT-TYPE       = COEFFICIENTS
   OUTPUT-MIN       = 1
   OUTPUT-MAX       = 1
   COEFFICIENTS     = ( 1, 0 )
   ..
"ALWAYS1-BI-LINEAR" = CURVE-FIT       
   TYPE             = BI-LINEAR-T
   INPUT-TYPE       = COEFFICIENTS
   OUTPUT-MIN       = 1
   OUTPUT-MAX       = 1
   COEFFICIENTS     = ( 1, 0, 0, 0, 0 )
   ..
"FanFPLR865Cubic" = CURVE-FIT       
   TYPE             = CUBIC
   INPUT-TYPE       = COEFFICIENTS
   OUTPUT-MIN       = 0
   OUTPUT-MAX       = 1
   COEFFICIENTS     = ( 0, 0, 0, 1 )
   ..

$ *********************************************************
$ **                                                     **
$ **      Floors / Spaces / Walls / Windows / Doors      **
$ **                                                     **
$ *********************************************************

SET-DEFAULT FOR EXTERIOR-WALL   
   CONSTRUCTION     = "EXTCONS"
   HEIGHT           = 8.85827
   ..

"ae100" = FLOOR           
   AZIMUTH          = 360
   SHAPE            = NO-SHAPE
   FLOOR-HEIGHT     = 8.85827
   SPACE-HEIGHT     = 8.85827
   C-DIAGRAM-DATA   = *Detailed UI DiagData*
   ..
"SPACE-A" = SPACE           
   X                = 0
   Y                = 0
   Z                = 0
   AREA             = 516.668
   VOLUME           = 4576.78
   SHAPE            = NO-SHAPE
   TEMPERATURE      = ( 70 )
   PEOPLE-SCHEDULE  = ( "Constant" )
   NUMBER-OF-PEOPLE = ( 100 )
   PEOPLE-HG-LAT    = ( 20 )
   PEOPLE-HG-SENS   = ( 2.8928 )
   ..
"A-S-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 0
   Z                = 0
   WIDTH            = 19.685
   AZIMUTH          = 180
   ..
"A-E-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 19.685
   Y                = 0
   Z                = 0
   WIDTH            = 26.2467
   AZIMUTH          = 90
   ..
"A-N-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 19.685
   Y                = 26.2467
   Z                = 0
   WIDTH            = 19.685
   AZIMUTH          = 0
   ..
"A-W-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 26.2467
   Z                = 0
   WIDTH            = 26.2467
   AZIMUTH          = 270
   ..
"A-ROOF" = EXTERIOR-WALL   
   CONSTRUCTION     = "EXTCONS"
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 0
   Z                = 8.85827
   HEIGHT           = 26.2467
   WIDTH            = 19.685
   AZIMUTH          = 180
   TILT             = 0
   ..
"A-FLOOR" = EXTERIOR-WALL   
   CONSTRUCTION     = "EXTCONS"
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 0
   Z                = 0
   HEIGHT           = 26.2467
   WIDTH            = 19.685
   AZIMUTH          = 180
   TILT             = 180
   ..
"A-INTWAL" = INTERIOR-WALL   
   CONSTRUCTION     = "INTCONS"
   INT-WALL-TYPE    = INTERNAL
   HEIGHT           = 8
   WIDTH            = 40
   ..
"SPACE-B" = SPACE           
   X                = 200
   Y                = 200
   Z                = 0
   AREA             = 516.668
   VOLUME           = 4576.78
   SHAPE            = NO-SHAPE
   TEMPERATURE      = ( 72 )
   PEOPLE-SCHEDULE  = ( "Constant" )
   NUMBER-OF-PEOPLE = ( 100 )
   PEOPLE-HG-LAT    = ( 30 )
   PEOPLE-HG-SENS   = ( 25.172 )
   ..
"B-S-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 0
   Z                = 0
   WIDTH            = 19.685
   AZIMUTH          = 180
   ..
"B-E-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 19.685
   Y                = 0
   Z                = 0
   WIDTH            = 26.2467
   AZIMUTH          = 90
   ..
"B-N-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 19.685
   Y                = 26.2467
   Z                = 0
   WIDTH            = 19.685
   AZIMUTH          = 0
   ..
"B-W-WALL" = EXTERIOR-WALL   
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 26.2467
   Z                = 0
   WIDTH            = 26.2467
   AZIMUTH          = 270
   ..
"B-ROOF" = EXTERIOR-WALL   
   CONSTRUCTION     = "EXTCONS"
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 0
   Z                = 8.85827
   HEIGHT           = 26.2467
   WIDTH            = 19.685
   AZIMUTH          = 180
   TILT             = 0
   ..
"B-FLOOR" = EXTERIOR-WALL   
   CONSTRUCTION     = "EXTCONS"
   OUTSIDE-EMISS    = 0.0001
   INSIDE-SOL-ABS   = 0
   X                = 0
   Y                = 26.2467
   Z                = 0
   HEIGHT           = 26.2467
   WIDTH            = 19.685
   AZIMUTH          = 180
   TILT             = 180
   ..
"B-INTWAL" = INTERIOR-WALL   
   CONSTRUCTION     = "INTCONS"
   INT-WALL-TYPE    = INTERNAL
   HEIGHT           = 8
   WIDTH            = 40
   ..


$ *********************************************************
$ **                                                     **
$ **              Electric & Fuel Meters                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Electric Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Fuel Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Master Meters
$ ---------------------------------------------------------

"MASTER-METERS 1" = MASTER-METERS   
   MSTR-ELEC-METER  = "EM1"
   MSTR-FUEL-METER  = "FM1"
   ..


$ *********************************************************
$ **                                                     **
$ **      HVAC Circulation Loops / Plant Equipment       **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Pumps
$ ---------------------------------------------------------

"HW CIRC" = PUMP            
   MECH-EFF         = 1
   CAP-CTRL         = ONE-SPEED-PUMP
   ..
"CHW CIRC" = PUMP            
   MECH-EFF         = 1
   CAP-CTRL         = ONE-SPEED-PUMP
   ..


$ ---------------------------------------------------------
$              Condensing Units
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Circulation Loops
$ ---------------------------------------------------------

"HEATLOOP" = CIRCULATION-LOOP
   TYPE             = HW
   SIZING-OPTION    = PRIMARY
   LOOP-MIN-FLOW    = 1
   DESIGN-HEAT-T    = 160
   LOOP-PUMP        = "HW CIRC"
   ..
"COOLLOOP" = CIRCULATION-LOOP
   TYPE             = CHW
   SIZING-OPTION    = PRIMARY
   LOOP-MIN-FLOW    = 1
   DESIGN-COOL-T    = 44
   LOOP-PUMP        = "CHW CIRC"
   ..


$ ---------------------------------------------------------
$              Chillers
$ ---------------------------------------------------------

"CHILL" = CHILLER         
   TYPE             = ELEC-OPEN-REC
   CAPACITY         = 1e+006
   CHW-LOOP         = "COOLLOOP"
   CONDENSER-TYPE   = AIR-COOLED
   ..


$ ---------------------------------------------------------
$              Boilers
$ ---------------------------------------------------------

"BOIL" = BOILER          
   TYPE             = HW-BOILER
   CAPACITY         = -100
   HW-LOOP          = "HEATLOOP"
   RATED-HW-DT      = 50
   ..


$ ---------------------------------------------------------
$              Domestic Water Heaters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Heat Rejection
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Tower Free Cooling
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Photovoltaic Modules
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Electric Generators
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Thermal Storage
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Ground Loop Heat Exchangers
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Compliance DHW (residential dwelling units)
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **            Steam & Chilled Water Meters             **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Steam Meters
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Chilled Water Meters
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **               HVAC Systems / Zones                  **
$ **                                                     **
$ *********************************************************

"SPACE-AB-SYS" = SYSTEM          
   TYPE             = VAVS
   HEAT-SOURCE      = NONE
   ZONE-HEAT-SOURCE = HOT-WATER
   PREHEAT-SOURCE   = HOT-WATER
   RETURN-AIR-PATH  = DUCT
   MAX-SUPPLY-T     = 120
   HEATING-SCHEDULE = "ALWAYS-ON"
   HEAT-CONTROL     = COLDEST
   MIN-SUPPLY-T     = 55
   COOL-SET-T       = 55
   COOLING-SCHEDULE = "ALWAYS-ON"
   ECONO-LIMIT-T    = 99
   ENTHALPY-LIMIT   = 60
   PREHEAT-T        = 45
   OA-CONTROL       = FIXED
   FAN-SCHEDULE     = "ALWAYS-ON"
   FAN-CONTROL      = FAN-EIR-FPLR
   SUPPLY-STATIC    = 2
   SUPPLY-MECH-EFF  = 0.7
   SUPPLY-EFF       = 0.7
   MOTOR-PLACEMENT  = OUTSIDE-AIRFLOW
   FAN-PLACEMENT    = DRAW-THROUGH
   RETURN-STATIC    = 1
   RETURN-EFF       = 0.7
   FAN-EIR-FPLR     = "FanFPLR865Cubic"
   REHEAT-DELTA-T   = 90
   HW-LOOP          = "HEATLOOP"
   CHW-LOOP         = "COOLLOOP"
   COIL-BF          = 0.001
   COIL-BF-FFLOW    = "ALWAYS1-LINEAR"
   COOL-CTRL-RANGE  = 0.01
   COIL-BF-FPLR     = "ALWAYS1-LINEAR"
   ..
"ZONE-A" = ZONE            
   TYPE             = CONDITIONED
   ASSIGNED-FLOW    = 600
   EXHAUST-FLOW     = 200
   HEAT-TEMP-SCH    = "HEAT-A"
   COOL-TEMP-SCH    = "COOL-A"
   THERMOSTAT-TYPE  = TWO-POSITION
   SPACE            = "SPACE-A"
   ..
"ZONE-B" = ZONE            
   TYPE             = CONDITIONED
   ASSIGNED-FLOW    = 700
   EXHAUST-FLOW     = 300
   HEAT-TEMP-SCH    = "HEAT-B"
   COOL-TEMP-SCH    = "COOL-B"
   THERMOSTAT-TYPE  = TWO-POSITION
   SPACE            = "SPACE-B"
   ..


$ *********************************************************
$ **                                                     **
$ **                Metering & Misc HVAC                 **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Equipment Controls
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Load Management
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                    Utility Rates                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Ratchets
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Block Charges
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Utility Rates
$ ---------------------------------------------------------



$ *********************************************************
$ **                                                     **
$ **                 Output Reporting                    **
$ **                                                     **
$ *********************************************************

$ ---------------------------------------------------------
$              Loads Non-Hourly Reporting
$ ---------------------------------------------------------

LOADS-REPORT    
   VERIFICATION     = ( ALL-VERIFICATION )
   SUMMARY          = ( ALL-SUMMARY )
   ..


$ ---------------------------------------------------------
$              Systems Non-Hourly Reporting
$ ---------------------------------------------------------

SYSTEMS-REPORT  
   VERIFICATION     = ( SV-A, SV-B )
   SUMMARY          = ( SS-A, SS-J, SS-K, SS-F )
   ..


$ ---------------------------------------------------------
$              Plant Non-Hourly Reporting
$ ---------------------------------------------------------

PLANT-REPORT    
   VERIFICATION     = ( PV-A )
   SUMMARY          = ( ALL-SUMMARY )
   ..


$ ---------------------------------------------------------
$              Economics Non-Hourly Reporting
$ ---------------------------------------------------------



$ ---------------------------------------------------------
$              Hourly Reporting
$ ---------------------------------------------------------

"GLOBALVARS" = REPORT-BLOCK    
   VARIABLE-TYPE    = GLOBAL
   VARIABLE-LIST    = ( 3, 4, 5, 18, 10 )
   ..
"ZONERB-1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SPACE-A"
   VARIABLE-LIST    = ( 12, 41, 42, 43, 44, 40 )
   ..
"ZONERB-2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SPACE-B"
   VARIABLE-LIST    = ( 12, 41, 42, 43, 44, 40 )
   ..
"SYSZNRB-1" = REPORT-BLOCK    
   VARIABLE-TYPE    = "ZONE-A"
   VARIABLE-LIST    = ( 6, 7, 14, 31, 32, 33, 9, 1, 2 )
   ..
"SYSZNRB-2" = REPORT-BLOCK    
   VARIABLE-TYPE    = "ZONE-B"
   VARIABLE-LIST    = ( 6, 7, 14, 31, 32, 33, 9, 1, 2 )
   ..
"SYSRB-T" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SPACE-AB-SYS"
   VARIABLE-LIST    = ( 10, 48, 6, 3, 1, 2, 4, 5, 13, 14, 17, 20, 21, 39, 40, 
         27, 28 )
   ..
"SYSRB-F" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SPACE-AB-SYS"
   VARIABLE-LIST    = ( 19, 20, 21, 49, 50 )
   ..
"SYSRB-W" = REPORT-BLOCK    
   VARIABLE-TYPE    = "SPACE-AB-SYS"
   VARIABLE-LIST    = ( 36, 37, 38, 35, 21, 56, 57, 58, 126, 127 )
   ..

"LdsRptGlobal" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "LDS-REPORT-A"
   REPORT-BLOCK     = ( "GLOBALVARS" )
   ..
"LdsRptZone" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "LDS-REPORT-A"
   REPORT-BLOCK     = ( "ZONERB-1", "ZONERB-2" )
   ..
"SysRptZone1" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "SCH-REPORT-A"
   REPORT-BLOCK     = ( "SYSZNRB-1" )
   ..
"SysRptZone2" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "SCH-REPORT-A"
   REPORT-BLOCK     = ( "SYSZNRB-2" )
   ..
"SysRpt1" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "SCH-REPORT-A"
   REPORT-BLOCK     = ( "SYSRB-T" )
   ..
"SysRpt2" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "SCH-REPORT-A"
   REPORT-BLOCK     = ( "SYSRB-F" )
   ..
"SysRpt3" = HOURLY-REPORT   
   REPORT-SCHEDULE  = "SCH-REPORT-A"
   REPORT-BLOCK     = ( "SYSRB-W" )
   ..


$ ---------------------------------------------------------
$              THE END
$ ---------------------------------------------------------

END ..
COMPUTE ..
STOP ..
